# Keil uVision project project.uvprojx, settings and files
target project (6220000::V6.22::ARMCLANG)
  device: GD32L233KB GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0006000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233
  c include: ..\CORE\Inc;..\Drivers\GD32L23x_Firmware_Library_V2.2.0\GD32L23x_standard_peripheral\Include;..\Drivers\GD32L23x_Firmware_Library_V2.2.0\CMSIS\GD\GD32L23x\Include;..\Drivers\SEGGER_RTT_V820\Config;..\Drivers\SEGGER_RTT_V820\RTT;..\Libraries\elog\inc;..\Libraries\printf;..\Middlewares\BasicOS;..\Drivers\ws2812b\src;..\Drivers\ws2812b\interface;..\Drivers\fm175xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group CORE
    ../CORE/Src/: gd32l23x_it.c main.c systick.c gd32l23x_eval.c ws2812_thread.c thread_rfid.c
  group MIddlewares/BasicOS
    ../Middlewares/BasicOS/: basic_os.c cb_basic_os.c
    ../Middlewares/BasicOS/port/arm_m3/: port_mdk.s cpu.c
  group Drivers/GD32L23x_Firmware_Library
    ../Drivers/GD32L23x_Firmware_Library_V2.2.0/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_can.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Drivers/Startup
    ../Drivers/GD32L23x_Firmware_Library_V2.2.0/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ../Drivers/GD32L23x_Firmware_Library_V2.2.0/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l233xx.s
  group Drivers/ws2812
    ../Drivers/ws2812b/src/: driver_ws2812b.c drv_2812b.c
    ../Drivers/ws2812b/interface/: driver_ws2812b_interface.c
  group Drivers/Seeger_RTT
    ../Drivers/SEGGER_RTT_V820/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Drivers/SEGGER_RTT_V820/Config/: SEGGER_RTT_Conf.h
  group Libraries/printf
    ../Libraries/printf/: printf.c printf_config.h port_printf.c
  group Libraries/elog
    ../Libraries/elog/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Libraries/elog/port/: elog_port.c
    ../Libraries/elog/inc/: elog_cfg.h
  group Drivers/fm175xx
    ../Drivers/fm175xx/: reader_api.c fm175xx_port.c
software components: CMSIS:CORE 6.1.0
